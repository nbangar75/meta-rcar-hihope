require ${@"core-image-renesas-add.inc" if "rcar-gen3" in d.getVar("OVERRIDES") else ""}
